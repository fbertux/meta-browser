# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6119b33dec26d2c34ee9c51fc8762d89"
SRC_URI[sha256sum] = "94d82f9dcf552f6e696e14d17ea9da388de8f5231e72bed6a0eef8b7426f6097"
