# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fcad835567c5c4fa92d896531e41e9f"
SRC_URI[sha256sum] = "c38b1152552c91e0531eb4536b2727bc72c1c9397679d8b42003dbf7dab1be7d"
