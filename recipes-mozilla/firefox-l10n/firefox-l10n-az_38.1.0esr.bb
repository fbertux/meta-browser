# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c81302396e047cf034970e46121e5914"
SRC_URI[sha256sum] = "a29a1f0362aa53c7ea42e500478d2218e6e3e356c7305b249c65f078218fb272"
