# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "068422bd9da246caec28626a924427ff"
SRC_URI[sha256sum] = "921ff1abd17da602be91dcd9ddf7f0655bb97231840ac72f964252bacfdcfcf9"
