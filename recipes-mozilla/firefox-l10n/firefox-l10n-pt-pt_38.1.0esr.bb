# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aba087a5675cf04a3214f494f001467"
SRC_URI[sha256sum] = "23e456c3550b31d7596956dd9739ef317ae742137419d426a4326f277e1c0206"
