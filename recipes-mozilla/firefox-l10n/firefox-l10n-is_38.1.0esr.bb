# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d974e29072aac46a91ad5d185819cbb8"
SRC_URI[sha256sum] = "fa4eca6ec46e110683178b282f4bd3cc6b47b315e4ddbd34cd99b8c00676b297"
