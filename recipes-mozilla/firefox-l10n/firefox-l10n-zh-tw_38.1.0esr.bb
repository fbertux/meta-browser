# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b7519f55cdb9781ba347b336af31893"
SRC_URI[sha256sum] = "e3ec89fe112a80d424e25934d21de61efbde5e6680ce2aece0c37a04d96be91c"
