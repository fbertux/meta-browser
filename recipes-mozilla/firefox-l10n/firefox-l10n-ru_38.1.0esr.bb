# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ebcaceb49a3ec680a01da7d1eb102a8"
SRC_URI[sha256sum] = "b2c612a33a7e7126343644b3931749cd9de1421f8bb1aad283087f0ede074c31"
