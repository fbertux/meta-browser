# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "340e9a4e3023b70bb745b0882f06d41e"
SRC_URI[sha256sum] = "874f22b8c19d7fe417496c6916b150c7d51a7021e5e73809a542799238c194fd"
