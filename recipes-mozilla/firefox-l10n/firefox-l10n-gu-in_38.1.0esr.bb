# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec49077f23d97c84982ac9b93b152ff2"
SRC_URI[sha256sum] = "dc03e9021e27b9c5d41be2c9e569da7165176f2139872fc5694500edd71e7102"
