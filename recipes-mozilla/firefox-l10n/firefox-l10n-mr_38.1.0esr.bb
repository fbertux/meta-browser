# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "249f311ce8221541cd662af7980ec91b"
SRC_URI[sha256sum] = "dd9caa414cc4ba76ec4161b246612cb008585b5662b4c911d1ca7058e86a54a5"
