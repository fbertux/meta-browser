# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e9330c7d9c04ef678242442a9944e3c"
SRC_URI[sha256sum] = "d5f5ae891561d7ea891f9eaeee4a417e76159f8ee2b6402580d71e155de5bf23"
