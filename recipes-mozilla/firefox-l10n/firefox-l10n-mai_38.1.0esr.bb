# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d37f7a584c8815933249388ae04d9b98"
SRC_URI[sha256sum] = "27473c24c7f66a9ed31ccda36d04bf98cc81f699bdfe4c5958de0abd9c5c6824"
