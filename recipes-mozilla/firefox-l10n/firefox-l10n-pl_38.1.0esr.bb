# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d8fdde4cb7e101c99b8329ebdaf9e5d"
SRC_URI[sha256sum] = "8b88410da0376d2c14ccc3e3c0eb8a0031d60d048aebba176100854a17bc16b4"
