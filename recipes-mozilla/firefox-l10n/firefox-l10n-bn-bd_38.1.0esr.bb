# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "562c25f301bbfed7a5f29283ab7cb6d7"
SRC_URI[sha256sum] = "2ca791e8a573f76f60698b3b634cf9c0768eee657ba6e99f65c0f8979e152216"
