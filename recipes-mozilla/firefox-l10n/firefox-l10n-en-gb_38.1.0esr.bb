# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00fabb5a17ac6bb957d0efd955fe3ae1"
SRC_URI[sha256sum] = "3f80590f27a73d5cb50b56b7658c38f4378f0bb1b84d3da4c2e0cd9a7b8f4120"
