# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33db4b70d1158157290c9eb6db05ed81"
SRC_URI[sha256sum] = "ac159c4a6b9dfb3b838dd757350cdfa92d7322c772e46bf79fbfce8d7e03b433"
