# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f342bea65cbe4a9a1ee7a67b4bb63a44"
SRC_URI[sha256sum] = "87e28415879608af646ab9a531108c74b18a8b94f7a472439841ed7b79240537"
