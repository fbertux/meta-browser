# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e839184a81c8c274050bdd513c68b19e"
SRC_URI[sha256sum] = "bfe8b26cffb80f7cc0824dc08546f31d54da190bf8fd342b12204ecdc85977e7"
