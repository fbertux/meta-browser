# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f78256a60663cd7a763c78ac0953ef80"
SRC_URI[sha256sum] = "f0fc43a9cfde17cb71a3c1adef1ec4ae53201d0246528216f7c62fa93d5ca621"
