# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65537f2f770d1ae86ddeadc51403e662"
SRC_URI[sha256sum] = "8e416c8c930e09adb020ede16d420fd94a4e0e169d3a40213e33db94dee44d6b"
