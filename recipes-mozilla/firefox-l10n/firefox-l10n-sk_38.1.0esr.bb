# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0b51e55614e852fcb37dcf37593defb"
SRC_URI[sha256sum] = "2fb1510e200824e455dee3492c8de7c0dd6bc4925307c5069d454fdc9513ca9b"
