# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb60c204531170f364b83f7263d45888"
SRC_URI[sha256sum] = "cb840656488d9044aa2042805f95458720fbcbb19e6fbd8beca197a9101817d1"
