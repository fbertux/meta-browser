# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78e784797c3e758ff8c31f0c77e1e8b8"
SRC_URI[sha256sum] = "b664469d76782fe549f582b79cb88d8350d439038ee1eaa7a7388fd5b3cb1eff"
