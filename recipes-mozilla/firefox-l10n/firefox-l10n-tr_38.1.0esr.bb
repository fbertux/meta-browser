# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64765183a59daec621cd3f6859f7b07d"
SRC_URI[sha256sum] = "c7eac37f05b3a4afc073e85c9a065f343cc40b0cdba17fb8dd7219bc175c7723"
