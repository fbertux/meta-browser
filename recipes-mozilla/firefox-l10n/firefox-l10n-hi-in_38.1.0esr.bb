# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2240e7787842a165f302f9e7f185e996"
SRC_URI[sha256sum] = "3404e4a912049d583508619d92fb37663629cddc09f91f2c6f6e007fcbd1a281"
