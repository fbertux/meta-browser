# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a86a9ffae21dd6b6116eaa8b500a904"
SRC_URI[sha256sum] = "f305e7a119c349ec71d4000517f315867f8174147dbbf6178a715e27e9aca29b"
