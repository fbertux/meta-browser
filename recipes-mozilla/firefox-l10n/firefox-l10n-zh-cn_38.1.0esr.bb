# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57ca483c3ac445d04f042283a2ec8ee2"
SRC_URI[sha256sum] = "0dbc3ac200290bdb5514c2076f5a1459442b4e3ee235ef29216384f2ad06d61f"
