# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e99ad6dd777a63122228025658739a"
SRC_URI[sha256sum] = "4caa6c2e11b1c0d9184cc688fcb5f9534ab74a1d87c2d7624a83c0fc1ea4699d"
