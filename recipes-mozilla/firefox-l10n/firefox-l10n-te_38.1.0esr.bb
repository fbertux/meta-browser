# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2afd6363c5c6beca384a0e58ed319b11"
SRC_URI[sha256sum] = "47024b3c034826560b19281b5346d3c79b46b86c308d15c98acc5898545c47a5"
