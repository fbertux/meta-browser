# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3224f35ed8c4b6e33d86e1d4db74632"
SRC_URI[sha256sum] = "aa8e47ac74821a900eac826459e9fefb0eb8c0de77ee1b5246a55e23a369f4b8"
