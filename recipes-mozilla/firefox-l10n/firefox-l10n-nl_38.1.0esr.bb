# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f416f4a1d89fad8102ae9d889db2ca3a"
SRC_URI[sha256sum] = "8d1532bbbb2a843babfd5b46909f0af1457fc8c9c14145b693ad0ff91b3e90ef"
