# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fad8aba3bbdf4786036b5973330ff67a"
SRC_URI[sha256sum] = "1a4c6835db2ba384767f6ceddf021a30b61c1d29f17577cf2f7330e3358c9ff7"
