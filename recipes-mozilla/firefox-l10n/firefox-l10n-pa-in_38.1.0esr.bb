# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc19284fafa8a59f8c09da3c47ab02fe"
SRC_URI[sha256sum] = "d3ee939b7914194a87f5ea3b24e569c3c9486ca3d0b997e8303c2c9c42b3bf76"
