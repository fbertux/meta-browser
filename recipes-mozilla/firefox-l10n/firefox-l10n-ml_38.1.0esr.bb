# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd919ea5dc7787e8af6134a19cf17ba5"
SRC_URI[sha256sum] = "f4d488f0207854450945af1230b70db6773bd94bad6804fdba4215bba921734f"
