# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f3f64e2f7de0beb72034617facf5743"
SRC_URI[sha256sum] = "57ee679bb3532a0e9289827d4fb421598683ea8168656889edddcff1e21bb6b9"
