# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5902938f93ddcf1dae69cc9cfff402d"
SRC_URI[sha256sum] = "9b17997524d839b610e60b42cae25c512ea93f3fedad473e723a91289f839ca5"
