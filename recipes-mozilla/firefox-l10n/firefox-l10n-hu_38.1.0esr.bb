# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49e445eba9d822ef33d915d1191ca6ec"
SRC_URI[sha256sum] = "93ace7ddee6b87c2a3cdfeedce151ced7354d3504d0d7e1aee8f2368094cabc0"
