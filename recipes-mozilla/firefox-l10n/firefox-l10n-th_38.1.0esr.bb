# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62fa4b78060f709a961da054d4e113ef"
SRC_URI[sha256sum] = "f99a2d738ee379bde70fc472626611365054eb25165c613824180d8ee7d53454"
