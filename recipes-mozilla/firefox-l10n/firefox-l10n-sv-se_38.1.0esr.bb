# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c50ab74e4e31a6fcdc3fa4b34cf9633e"
SRC_URI[sha256sum] = "724e6ed7ad69ea5a612185851d1bcc39eb46e9cdaaee9032609637516b2fb4fc"
