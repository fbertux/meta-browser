# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57707df5b1b26ada2bd1e7a8d0659f9a"
SRC_URI[sha256sum] = "36fe4e6fc9b319f65b81ab0f9f8eda2b185ff175b6d4999799489365154142e6"
