# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f739f18a0b666fcdd17c219be7569161"
SRC_URI[sha256sum] = "53aca9e35a77091be291a3d2246ada0110d71e0451018c20d9a8c1f40dd2b2ae"
