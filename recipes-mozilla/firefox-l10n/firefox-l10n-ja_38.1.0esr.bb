# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80b70e68a121ce539296770dac1b68d7"
SRC_URI[sha256sum] = "456e16ba61c0bb904cbfb3d05b184d6fc9d7cac7f346c7b38d9fe230af96e96d"
