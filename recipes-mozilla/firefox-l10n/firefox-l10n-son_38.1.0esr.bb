# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d6572f6d6ab9a8539f38344bdc6a6e5"
SRC_URI[sha256sum] = "9fa1b158b3ca08335ca6c9bcf70fd76e6b4baab6cfdb667475188aaacc2f2193"
