# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bd9e27be0ec570fbb78b5f4bc4af018"
SRC_URI[sha256sum] = "4d67723435a899817745f8141c7671fd8c0ed899db6b9fc040a7cf77a997113a"
