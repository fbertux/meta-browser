# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bab4b2e590cb7f089e7cf8f5c7e5928"
SRC_URI[sha256sum] = "cd38ec29af9fbbc27ad61330d2804d57f999c98cebccf6333aa58d55c4e1db87"
