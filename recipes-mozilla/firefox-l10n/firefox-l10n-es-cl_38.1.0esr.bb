# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09e229422e3520d8803b546c3bd70b7c"
SRC_URI[sha256sum] = "f5979bcfc6576cd6796a555617966c4f7c42d90bba52dc281824d09f7ca2ba01"
