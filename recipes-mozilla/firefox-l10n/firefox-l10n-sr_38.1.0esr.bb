# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fea4af86108449015aa0bd60e6d3c60c"
SRC_URI[sha256sum] = "f63271245f4919db7b86e9740a5128f50db750fe747e98343b1641291e7be1d3"
