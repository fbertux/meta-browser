# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0da6038ca1ef117c75832f070e7847a1"
SRC_URI[sha256sum] = "d8ad198ce7afef708e7974384cac5b646efa58c1b914c0e58a0c19569276ac9d"
