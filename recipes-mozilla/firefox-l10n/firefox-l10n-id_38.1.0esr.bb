# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34f766087e8e9fd1c31e28b45551e409"
SRC_URI[sha256sum] = "f37f250ba26bdf7cdb1f3d47a6bf7f7feb90ebd82da1a55ff4f11932af1da1e5"
