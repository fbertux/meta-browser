# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d500c666fdff35f762bf2e278115c3b"
SRC_URI[sha256sum] = "f6f06bac70b7edd570510deed989e3184d08a42a7e49a7e7960ed1f6a705e0a0"
