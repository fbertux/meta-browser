# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "878911de3baf2132e7e658d53f2d05d2"
SRC_URI[sha256sum] = "90bbd088bff3a41dfc752f695f0184e68d5621ffdaa17536a989067bc2f4f7de"
