# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28345a1450dcf1164b0ed4ac17b5e3ff"
SRC_URI[sha256sum] = "92b42a21fdd59775f65f13316e875f93f7478695aa70ab02016f3145c79a3aea"
