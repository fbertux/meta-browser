# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9657645265ebaae0334cb8c32f5b26a"
SRC_URI[sha256sum] = "0a4c45516ba00ab84b2744690ff4e70ef624825238fa4c4cd6345db68be158e5"
