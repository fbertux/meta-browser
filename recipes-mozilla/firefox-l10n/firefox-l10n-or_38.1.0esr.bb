# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "922182f30c2771a41c86536030463475"
SRC_URI[sha256sum] = "1297c29d98f2b1952d05f50417ba383c28505dd316ab8fd7179be6f6805ba892"
