# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ac564760f4bb1981e45df99f327c4c3"
SRC_URI[sha256sum] = "a23e9ea357bd08c5029d31d6865516efc5ff3aa8504dae8dc316af5efc859fa9"
