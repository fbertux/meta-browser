# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b4d1a3d4fe2e458b1c70cd8a9d00a7e"
SRC_URI[sha256sum] = "dbecee3b6d22ff49680d412a338a8e94d6f759c62110cb55ed6aa21f11537a0a"
