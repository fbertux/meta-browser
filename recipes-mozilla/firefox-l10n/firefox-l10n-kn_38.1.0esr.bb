# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f42f3d2e0f42ace73875fae7dc3b83"
SRC_URI[sha256sum] = "72d4b3da5a920975904ba4f17b55826685ec71ffc4e952a946142210e2ae95eb"
