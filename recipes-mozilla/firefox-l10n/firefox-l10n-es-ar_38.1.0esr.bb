# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97692ddac8be0eff7bbb37c42f9d1ce8"
SRC_URI[sha256sum] = "7410081864264d57267ffb4795aac402a72d30e369e4aa6ec2df6501c77ead8f"
