# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b4bffa563166b527ec63f7dac498458"
SRC_URI[sha256sum] = "47eef2d1bfa6e5594cd8835bddca7bfd5019aac1553b54b05c1c749fad659dda"
