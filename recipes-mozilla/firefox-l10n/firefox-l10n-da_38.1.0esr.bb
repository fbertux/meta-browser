# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4e12625a46364d9553ffb7f89d45999"
SRC_URI[sha256sum] = "2b339c9a73067076f4ca8b28d9d8543064be5616dd4db50cf0bf1ed0e4cea3c2"
