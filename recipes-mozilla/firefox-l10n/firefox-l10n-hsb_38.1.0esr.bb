# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80f72c73cbf30ac87227747487c5f4b9"
SRC_URI[sha256sum] = "b36779a40c56839cb9b6a78eca688704dcc5c202921493726640805580b7bf6e"
