# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63c2aa46598bbab293f45f08d1d1b0ca"
SRC_URI[sha256sum] = "96e8b36888ccadce8d576208a76ab6522c3148c501bc35549e25bce545c11a01"
