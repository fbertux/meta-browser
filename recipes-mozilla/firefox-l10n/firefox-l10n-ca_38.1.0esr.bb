# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98c33a0977249202ffd3e8e668d8cf38"
SRC_URI[sha256sum] = "53c42f1501f90ddd9259ca255baae8a7ea6a1055fa88acc0cd1de9d8a20db2b9"
