# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2edd2d01a0df1f0c3788d924f545bee8"
SRC_URI[sha256sum] = "464c9b57d03fbaff4a6241dfa492623a338018a609e2289defeba196ab454b95"
