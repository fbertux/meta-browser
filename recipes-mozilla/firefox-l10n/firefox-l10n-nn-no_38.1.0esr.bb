# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e12968f42c34c603bd52eb78380aa371"
SRC_URI[sha256sum] = "732a5be1501711e2aed2a5073dd6a3726095b8d3940765e4b368c74c2ad32c59"
