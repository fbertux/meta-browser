# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "225bce77cf77ee7c9c2f6b5bd12a829a"
SRC_URI[sha256sum] = "d5278f3ec2826f929ac6dafc9d6c4516c2b872e0ab9d98eb192a3d23b786d584"
