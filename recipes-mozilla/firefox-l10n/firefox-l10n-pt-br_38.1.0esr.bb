# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67d49a9d6d520a2945c00c41ac8838ce"
SRC_URI[sha256sum] = "f1b89e40d210497e3a7ef45b7acbf42c9d0b0b7990efd35d94f04fd0247dfc53"
