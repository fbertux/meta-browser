# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60419b80bc1181789cc4fd5cc3781f7d"
SRC_URI[sha256sum] = "42948d7424e1554ce71e34d34c63b1bd3b94bf067845b8826576591aeeba3bb9"
