# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "937906f7fe5f110c025d091c43e740dc"
SRC_URI[sha256sum] = "02de4fd1753d33e6b0c1d81dce2beec09dd01c1bff2c0e82864ec0700971bb68"
