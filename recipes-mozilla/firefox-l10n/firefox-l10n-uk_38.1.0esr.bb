# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c32b5ca621bcc777ed79ca966414f188"
SRC_URI[sha256sum] = "6c68750ac5d4dab03b6c93d7694d8a8c430e95d9ad103a86c2477089fd678d99"
