# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a4c7f66f879be1912c702f51f24ace4"
SRC_URI[sha256sum] = "ecac2d452d2a4e4165970a1aed2a0ae6bff8212c0d6dc0687e5782758d5d72d9"
