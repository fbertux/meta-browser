# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b375e7ecb0467bf5b177b23503bafde"
SRC_URI[sha256sum] = "6e2d2ac3b859eedc499041e2961cc1bf4b92316dd59526f14ff694fb4c2067b4"
