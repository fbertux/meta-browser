# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15c4121224dcaafe12ff4e72fd175e51"
SRC_URI[sha256sum] = "5096d0dc1ff5e547fb07906e0a3183b3117a6453311fb28afa991db5c34c95d1"
