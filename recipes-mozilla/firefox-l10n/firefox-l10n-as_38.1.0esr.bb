# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "538c618bad9f6eac0599be291e484ea9"
SRC_URI[sha256sum] = "1628e61d5bb7e7c4cbdff288ca2e6d8623578ccf12797e63b27864e68be21c1c"
