# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1326112e757409ae4496086f2ad064ca"
SRC_URI[sha256sum] = "76e0e0480e62cc5187e6cf97845d61d835a16b883582cd8a27ef2b6e74c3d69c"
