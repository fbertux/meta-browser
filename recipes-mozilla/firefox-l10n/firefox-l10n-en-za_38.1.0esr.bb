# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e7473548db433a69cc8525f61f67eaf"
SRC_URI[sha256sum] = "6d3a854cffcb9a6ff37a6ae4b2b9a91da3fd16914ea4cd70f69ad3039b960ceb"
