# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ffd2d8c86aa29f7bd891bb7d5b93963"
SRC_URI[sha256sum] = "bb0aca584ae740caa4cd2adeab2de09670c38ec8dd0241512318201b3ed6d761"
