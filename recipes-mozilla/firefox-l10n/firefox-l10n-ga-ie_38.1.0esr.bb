# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e42d67545b79a3f6e44bb2c47d7a7d8"
SRC_URI[sha256sum] = "39ae1a583ac7be57fb3631e98734008823fe735ac679a173efe8729ef66e295c"
