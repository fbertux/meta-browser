# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ee48d5ce756f0bfa324013ba5496a4e"
SRC_URI[sha256sum] = "6d1a14149420b2d851673c58308cff8b5218a4e9835b60d5a5274d2edf367635"
