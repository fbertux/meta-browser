# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5241d6a6e24b9c9eb317bb33e18e89d1"
SRC_URI[sha256sum] = "ff7583b04c4e57128f0165ecd94488bca77cf4a84bf0284f313f9aca2c885faf"
