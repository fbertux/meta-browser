# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd0a414b788c6bae316c33e69c45b0c"
SRC_URI[sha256sum] = "98487a75721efbb651b30d94fc00edac8962ca4aa0f356c714aae1761ed1650b"
