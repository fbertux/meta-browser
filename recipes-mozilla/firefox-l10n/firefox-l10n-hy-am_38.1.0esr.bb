# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a47d0f198ea96f2689d5d0f3aac89869"
SRC_URI[sha256sum] = "8c6a5918df7c1bdd36cdf9a5fe44400c53e2e8998dc910ad71ff29178299d63b"
