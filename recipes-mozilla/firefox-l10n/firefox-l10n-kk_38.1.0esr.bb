# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4b6d8bf760fecad3cb775d590e84394"
SRC_URI[sha256sum] = "0c10adeca506e653e464285b1feaf049d79dbcb45e1820dfe6cbb13198422c5a"
