# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fcfd77352c1f060246d0ba83a4b05cc"
SRC_URI[sha256sum] = "00c98155bc447385340e2c1b08ecfac7f4405b8b843c0603ab39a65b037f49e3"
