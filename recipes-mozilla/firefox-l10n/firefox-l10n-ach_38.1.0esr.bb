# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c39e7a69147c49051208db276aea67fc"
SRC_URI[sha256sum] = "d8d0439db26597a0d869e5467bb849bc77c1786b0c2df3a16cf91801523cbebb"
