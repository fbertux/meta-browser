# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c3ea09980299842646456dd9b4e41d5"
SRC_URI[sha256sum] = "b94aff6d6093856b1726b1aa8d6ffa0ad2db3a897ea9ad6a5589fbffac6580a9"
