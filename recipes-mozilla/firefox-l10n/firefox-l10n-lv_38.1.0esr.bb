# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "000bc59fb0670fa3a004f987a98e1c60"
SRC_URI[sha256sum] = "3f88098b580f7591a9a435ba93f06e73f6adb312d9a19ad4b756768b93bd3b1b"
