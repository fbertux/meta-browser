# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ffae0f26fe1dfa946850333f01fce73"
SRC_URI[sha256sum] = "75c704a30c99d4bd6b0a99945709dd88c86b8859ffe448ed59b0b9af51c76c7b"
